# Keil uVision project mlndr.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mlndr +hex
  c flags: Optim=1
  c include: ..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\lib\MDR32F9Qx_StdPeriph_Driver\inc;..\..\lib\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: button.c button.h clk.c clk.h led.c led.h main.c type_custom.h
  group DeviceSupport
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/: system_MDR32F9Qx.c system_MDR32F9Qx.h
  group StdPeriphDriver
    ../../lib/MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_port.h MDR32F9Qx_rst_clk.h
    ../../lib/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
